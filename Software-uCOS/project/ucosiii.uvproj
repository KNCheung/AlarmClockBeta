# Keil uVision project ucosiii.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ucosiii +hex
  c flags: Optim=1
  c include: ..\APP;..\BSP;..\STM32LIB\includes;..\uC-CPU;..\uC-LIB;..\uCOS-III\Ports;..\uCOS-III\Source
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group ucosiii
    ../uCOS-III/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
    ../uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uc-lib
    ../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uc-cpu
    ../uC-CPU/: cpu.h cpu_a.asm cpu_c.c cpu_core.c cpu_core.h cpu_def.h
  group startup
    ../STM32LIB/startup/: startup_stm32f10x_hd.s
  group stmlib
    ../STM32LIB/includes/: core_cm3.h misc.h stm32f10x.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h system_stm32f10x.h
    ../STM32LIB/src/: core_cm3.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group user
    ../APP/: app.c app_cfg.h app_vect.c cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h os_type.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c
  group bsp
    ../BSP/: bsp.c bsp.h bsp_int.c bsp_os.c bsp_os.h DS18B20.C REG.c TIM.c IIC.c IR.c
